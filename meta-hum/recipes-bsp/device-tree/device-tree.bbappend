FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = "file://system-bsp.dtsi \
                "
